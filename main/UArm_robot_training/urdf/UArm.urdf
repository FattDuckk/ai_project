Commit message: fixed logging issue. crashes stopped

File: main/UArm_robot_training/urdf/UArm.urdf (robot description, URDF)
Before this commit: robot UArm, 8 links, 7 joints
Links:
- link camera_link: mass None -> 0.0001
